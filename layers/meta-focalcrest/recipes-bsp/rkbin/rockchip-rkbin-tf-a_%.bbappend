# SPDX-License-Identifier: MIT
# Copyright (c) 2026 Focalcrest

COMPATIBLE_MACHINE:rk3576 = "rk3576"

RKBIN_BINDIR:rk3576 ?= "bin/rk35/"
RKBIN_BINVERS:rk3576 ?= "v1.15"
RKBIN_BINFILE:rk3576 ?= "rk3576_bl31_${RKBIN_BINVERS}.elf"
